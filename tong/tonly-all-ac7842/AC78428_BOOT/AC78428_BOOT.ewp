# IAR project AC78428_BOOT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AC78428xILA AutoChips AC78428xILA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AC7842X
  ICCARM.CCIncludePath2: source; ..\AC78428_APP\ac7842x\Driver\include; ..\AC78428_APP\ac7842x\Device; ..\AC78428_APP\ac7842x\Device\include; ..\AC78428_APP\ac7842x\Device\config; ..\AC78428_APP\ac7842x\base\include; hal\include; sdk\include; commonLib\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AC78428_BOOT.hex
  ILINK.IlinkOutputFile: AC78428_BOOT.out
  ILINK.IlinkConfigDefines: __BUILD_TARGET__=0
  ILINK.IlinkIcfFile: AC7842x_flash_2048KB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: AC7842x_flash_2048KB.icf
  group ac78428/drivers/inc
    ../AC78428_APP/ac7842x/Driver/include/: AC784xx_Acmp_Reg.h AC784xx_Adc_Reg.h AC784xx_Can_Reg.h AC784xx_Ckgen_Reg.h AC784xx_Cmu_Reg.h AC784xx_Crc_Reg.h AC784xx_Cse_Reg.h AC784xx_Ctu_Reg.h AC784xx_Dma_Reg.h AC784xx_Eim_Reg.h AC784xx_Eio_Reg.h AC784xx_Esm_Reg.h AC784xx_Fls_Reg.h AC784xx_Gpio_Reg.h AC784xx_I2c_Reg.h AC784xx_Mcm_Reg.h AC784xx_Mpu_Reg.h AC784xx_Pbr_Reg.h AC784xx_Pct_Reg.h AC784xx_Pdt_Reg.h AC784xx_Pwm_Reg.h AC784xx_Rcm_Reg.h AC784xx_Rtc_Reg.h AC784xx_Sent_Reg.h AC784xx_Smu_Reg.h AC784xx_Spi_Reg.h AC784xx_Spm_Reg.h AC784xx_Timer_Reg.h AC784xx_Uart_Reg.h AC784xx_Wdg_Reg.h Acmp_Hal.h Acmp_Hal_Types.h Adc_Hal.h Adc_Hal_Types.h Can_Hal.h Can_Hal_Types.h Ckgen_Hal.h Cmu_Hal.h Cmu_Hal_Types.h Core_Hal.h Core_Hal_Types.h Crc_Hal.h Crc_Hal_Types.h Cse_Hal.h Ctu_Hal.h Dma_Hal.h eep_drv.h Eep_Hal.h Eim_Hal.h Eim_Hal_Types.h Eio_Common_Hal.h Eio_Hal_Types.h Eio_I2c_Hal.h Eio_I2s_Hal.h Eio_I2s_Hal_Types.h Eio_Uart_Hal.h Eio_Uart_Hal_Types.h Esm_Hal.h Esm_Hal_Types.h Fls_Hal.h Gpio_Hal.h Gpio_Hal_Types.h Hsm_Hal.h I2c_Hal.h I2c_Hal_Types.h Lin_Hal.h Lin_Hal_Types.h Mpu_Hal.h Pbr_Hal.h Pct_Hal.h Pdt_Hal.h Pwm_Hal.h Pwm_Hal_Types.h Rcm_Hal.h Rtc_Hal.h Sent_Hal.h Sent_Hal_Types.h Smu_Hal.h Smu_Hal_Types.h Spi_Hal.h Spi_Hal_Types.h Spm_Hal.h Timer_Hal.h Uart_Hal.h Uart_Hal_Types.h Wdg_Hal.h
  group ac78428/drivers/src
    ../AC78428_APP/ac7842x/Driver/src/: AC784xx_Ckgen_Reg.c AC784xx_Cse_Reg.c Acmp_Hal.c Adc_Hal.c Can_Hal.c Ckgen_Hal.c Cmu_Hal.c Core_Hal.c Crc_Hal.c Cse_Hal.c Ctu_Hal.c Dma_Hal.c eep_drv.c Eep_Hal.c Eim_Hal.c Eio_Common_Hal.c Eio_I2c_Hal.c Eio_I2s_Hal.c Eio_Uart_Hal.c Esm_Hal.c Fls_Hal.c Gpio_Hal.c I2c_Hal.c Mpu_Hal.c Pbr_Hal.c Pct_Hal.c Pdt_Hal.c Pwm_Hal.c Rcm_Hal.c Rtc_Hal.c Sent_Hal.c Smu_Hal.c Spi_Hal.c Spm_Hal.c Timer_Hal.c Uart_Hal.c Wdg_Hal.c
  group ac78428/platform
    ../AC78428_APP/ac7842x/Device/include/: AC7842x.h AC7842x_Features.h Core_AC784xx.h Debugout_AC784xx.h Device_Register.h Device_Types.h System_AC784xx.h
    ../AC78428_APP/ac7842x/base/include/: Compiler.h Compiler_Cfg.h CompilerAsm.h CompilerDefinition.h Hsm_FW_Version.h Misra_Deviations.h OsIf.h OsIf_Critical.h OsIf_Irq.h OsIf_Time.h Platform_Types.h Sdk_Version.h Std_Types.h
    ../AC78428_APP/ac7842x/Device/config/: Conf_AC784xx.h Device_Assert.h
    ../AC78428_APP/ac7842x/Device/src/: Debugout_AC784xx.c Exception_AC784xx.c System_AC784xx.c
    ../AC78428_APP/ac7842x/base/src/: OsIf.c OsIf_Critical.c
  group ac78428/startup
    ../AC78428_APP/ac7842x/Device/src/iar/: startup_ac7842x.s
  group commonLib
    commonLib/source/: crc8_16_32.c
    commonLib/include/: crc8_16_32.h
  group hal/inc
    hal/include/: flashHal.h logHal.h mpuHal.h peripheralHal.h
  group hal/src
    hal/source/: flashHal.c logHal.c mpuHal.c peripheralHal.c
  group sdk
    sdk/source/: firmwareUpdateSdk.c
    sdk/include/: firmwareUpdateSdk.h
  group source
    source/: clock_cfg.c clock_cfg.h main.c secureBoot.c secureBoot.h
