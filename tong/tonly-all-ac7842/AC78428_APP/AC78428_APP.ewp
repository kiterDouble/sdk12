# IAR project AC78428_APP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AC78428xILA AutoChips AC78428xILA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AC7842X
  ICCARM.CCIncludePath2: ac7842x\Driver\include; ac7842x\Device; ac7842x\User; ac7842x\Driver\src; ac7842x\Device\src; ac7842x\Device\include; ac7842x\Device\config; ac7842x\base\include; ac7842x\FreeRTOS; ac7842x\FreeRTOS\Source\include; ac7842x\FreeRTOS\Source\portable\IAR\ARM_CM4F; ac7842x\Hal\inc; source; source\commonLib\include; source\app\power_manage; source\app\can_cycle_send; source\sdk\include; source\app\diagnostic; source\app\ecall; source\app\gateway; source\app\mcu_cpu_sync; source\app\parameter_store; source\app\power_manage; source\app\project_configure; source\app\remote_control; source\app\remote_diagnostic; source\app\vehicle_data_to_cpu; source\app\vehicle_signal; source\app\j1939; source\app\secoc_config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ac7842x\FreeRTOS
  OBJCOPY.OOCOutputFile: AC78428_APP.hex
  ILINK.IlinkOutputFile: AC78428_APP.out
  ILINK.IlinkConfigDefines: __BUILD_TARGET__=2
  ILINK.IlinkIcfFile: AC7842x_flash_2048KB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ILINK.IlinkConfigDefines: __BUILD_TARGET__=1
  group (top)
    ./: AC7842x_flash_2048KB.icf
  group App
    source/: taskManage.c taskManage.h
  group App/can_cycle_send
    source/app/can_cycle_send/: canPeriodTask.c
  group App/diagnostic
    source/app/diagnostic/: eolTestSyncWithCpu.c eolTestSyncWithCpu.h taskDiagnostic.c taskDiagnostic.h taskDtcProcess.c taskDtcProcess.h udsDidFunction.c udsDidFunction.h udsEolTest.c udsEolTest.h udsSecurityCalculate.c udsSecurityCalculate.h
  group App/digital_key
    source/app/digital_key/: digital_key.c digital_key.h
  group App/ecall
    source/app/ecall/: taskEcallProcess.c
  group App/gateway
    source/app/gateway/: canGateWay.c canGateWay.h
  group App/j1939
    source/app/j1939/: j1939App.c j1939App.h
  group App/mcu_mpu_sync
    source/app/mcu_cpu_sync/: mcuMpuSyncTask.c
  group App/parameter_store
    source/app/parameter_store/: ParameterStoreManageApp.c
  group App/power_manage
    source/app/power_manage/: taskPowerManage.c
  group App/project_config
    source/app/project_configure/: projectConfigure.c version.c
  group App/remote_control
    source/app/remote_control/: remoteControl.c remoteControlCanSignal.c
  group App/remote_diagnostic
    source/app/remote_diagnostic/: remoteDiagnosticTask.c
  group App/vehicle_data_to_cpu
    source/app/vehicle_data_to_cpu/: canMsgDynamicConfigure.c canMsgDynamicConfigure.h canMsgSpiTransmit.c canMsgSpiTransmit.h canMsgToCpu.c canMsgToCpu.h canToCpuTest.c canToCpuTest.h ecuNodeMissingCheck.c ecuNodeMissingCheck.h taskVehicleDataToCpu.c taskVehicleDataToCpu.h
  group App/vehicle_signal
    source/app/vehicle_signal/: vehicleSignalApp.c vehicleSignalApp.h
  group Base/inc
    ac7842x/base/include/: Compiler.h Compiler_Cfg.h CompilerAsm.h CompilerDefinition.h Hsm_FW_Version.h Misra_Deviations.h OsIf.h OsIf_Critical.h OsIf_Irq.h OsIf_Time.h Platform_Types.h Sdk_Version.h Std_Types.h
  group Base/src
    ac7842x/base/src/: OsIf.c OsIf_Critical.c
  group CommonLib
    source/commonLib/source/: aes128.c crc8_16_32.c md5.c
  group Device
    ac7842x/Device/include/: AC7842x.h AC7842x_Features.h Core_AC784xx.h Debugout_AC784xx.h Device_Register.h Device_Types.h System_AC784xx.h
    ac7842x/Device/config/: Conf_AC784xx.h Device_Assert.h
    ac7842x/Device/src/: Debugout_AC784xx.c Exception_AC784xx.c System_AC784xx.c
    ac7842x/Device/src/iar/: startup_ac7842x.s
  group Driver/inc
    ac7842x/Driver/include/: AC784xx_Acmp_Reg.h AC784xx_Adc_Reg.h AC784xx_Can_Reg.h AC784xx_Ckgen_Reg.h AC784xx_Cmu_Reg.h AC784xx_Crc_Reg.h AC784xx_Cse_Reg.h AC784xx_Ctu_Reg.h AC784xx_Dma_Reg.h AC784xx_Eim_Reg.h AC784xx_Eio_Reg.h AC784xx_Esm_Reg.h AC784xx_Fls_Reg.h AC784xx_Gpio_Reg.h AC784xx_I2c_Reg.h AC784xx_Mcm_Reg.h AC784xx_Mpu_Reg.h AC784xx_Pbr_Reg.h AC784xx_Pct_Reg.h AC784xx_Pdt_Reg.h AC784xx_Pwm_Reg.h AC784xx_Rcm_Reg.h AC784xx_Rtc_Reg.h AC784xx_Sent_Reg.h AC784xx_Smu_Reg.h AC784xx_Spi_Reg.h AC784xx_Spm_Reg.h AC784xx_Timer_Reg.h AC784xx_Uart_Reg.h AC784xx_Wdg_Reg.h Acmp_Hal.h Acmp_Hal_Types.h Adc_Hal.h Adc_Hal_Types.h Can_Hal.h Can_Hal_Types.h Ckgen_Hal.h Cmu_Hal.h Cmu_Hal_Types.h Core_Hal.h Core_Hal_Types.h Crc_Hal.h Crc_Hal_Types.h Cse_Hal.h Ctu_Hal.h Dma_Hal.h eep_drv.h Eep_Hal.h Eim_Hal.h Eim_Hal_Types.h Eio_Common_Hal.h Eio_Hal_Types.h Eio_I2c_Hal.h Eio_I2s_Hal.h Eio_I2s_Hal_Types.h Eio_Uart_Hal.h Eio_Uart_Hal_Types.h Esm_Hal.h Esm_Hal_Types.h Fls_Hal.h Gpio_Hal.h Gpio_Hal_Types.h Hsm_Hal.h I2c_Hal.h I2c_Hal_Types.h Mpu_Hal.h Pbr_Hal.h Pct_Hal.h Pdt_Hal.h Pwm_Hal.h Pwm_Hal_Types.h Rcm_Hal.h Rtc_Hal.h Sent_Hal.h Sent_Hal_Types.h Smu_Hal.h Smu_Hal_Types.h Spi_Hal.h Spi_Hal_Types.h Spm_Hal.h Timer_Hal.h Uart_Hal.h Uart_Hal_Types.h Wdg_Hal.h
    ac7842x/Driver/src/hsmpackage/include/: HSM_Software.h
  group Driver/src
    ac7842x/Driver/src/: AC784xx_Ckgen_Reg.c AC784xx_Cse_Reg.c Acmp_Hal.c Adc_Hal.c Can_Hal.c Ckgen_Hal.c Cmu_Hal.c Core_Hal.c Crc_Hal.c Cse_Hal.c Ctu_Hal.c Dma_Hal.c eep_drv.c Eep_Hal.c Eim_Hal.c Eio_Common_Hal.c Eio_I2c_Hal.c Eio_I2s_Hal.c Eio_Uart_Hal.c Esm_Hal.c Fls_Hal.c Gpio_Hal.c I2c_Hal.c Mpu_Hal.c Pbr_Hal.c Pct_Hal.c Pdt_Hal.c Pwm_Hal.c Rcm_Hal.c Rtc_Hal.c Sent_Hal.c Smu_Hal.c Spi_Hal.c Spm_Hal.c Timer_Hal.c Uart_Hal.c Wdg_Hal.c
  group FreeRTOS
    ac7842x/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ac7842x/FreeRTOS/: FreeRTOSConfig.h
    ac7842x/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ac7842x/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group Hal/inc
    ac7842x/Hal/inc/: batteryHal.h bleHal.h canHal.h clockCheck.h cryptoHal.h ecallHal.h flashHal.h gSensorHal.h hal_port.h hsmHal.h logHal.h mpuHal.h peripheralHal.h powerManageHal.h qmi8a01zHal.h rtcHal.h securityHal.h timerHal.h watchdogHal.h
  group Hal/src
    ac7842x/Hal/src/: batteryHal.c bleHal.c canHal.c clockCheck.c cryptoHal.c ecallHal.c flashHal.c gSensorHal.c hsmHal.c logHal.c mpuHal.c peripheralHal.c powerManageHal.c qmi8a01zHal.c rtcHal.c securityHal.c timerHal.c watchdogHal.c
  group Sdk/inc
    source/sdk/include/: alarmSdk.h autosarNmSdk.h batterySdk.h canParseSdk.h canTpSdk.h commSdk.h firmwareUpdateSdk.h hsmSdk.h j1939Sdk.h j1939Tp.h logSdk.h mpuPowerSyncSdk.h nmConfig.h osekNmSdk.h osTimerSdk.h parameterSyncSdk.h powerManageSdk.h RemoteDiagnosticSdk.h secocSdk.h stateSyncSdk.h timeSyncSdk.h udsTp.h virtualTpSdk.h
  group Sdk/src
    source/sdk/source/: alarmSdk.c autosarNmSdk.c batterySdk.c canParseSdk.c canTpSdk.c commSdk.c firmwareUpdateSdk.c hsmSdk.c j1939Sdk.c j1939Tp.c logSdk.c mpuPowerSyncSdk.c osekNmSdk.c osTimerSdk.c parameterSyncSdk.c powerManageSdk.c RemoteDiagnosticSdk.c stateSyncSdk.c timeSyncSdk.c udsTp.c virtualTpSdk.c
  group User
    ac7842x/User/: clock_cfg.c main.c
